# Repository SkCubeSat/radsat-v1

File README.md:

# radsat-v1
Repo for RADSAT-SK OBC flight board

## KiCad design kicad/oresat-c3.kicad_pcb

Notes on the sheet:
Bill of Materials is kept in a Google Sheet Here: https://docs.google.com/spreadsheets/d/11vG1kWyrAjmbF5QJM-EhXmvQoF6O47japwYlHF802do/edit#gid=668351130
The Octavo OSD3358 schematics are heavily based on the Octavo Systems OSD3358-SM-RED platform, which seems to be released under an MIT-like license. Please see https://octavosystems.com/docs/osd3358-sm-red-schematics-pdf/
The OSD3358 design is also based on the beagleboard.org PocketBeagle. https://github.com/beagleboard/pocketbeagle

Parts:
C33, C65, C78: 100n; C_0603_1608Metric
C34, C35, C36, C93: 22u; C_1210_3225Metric
D8: GREEN; LED_0603_1608Metric
Q6: MMBT2907; SOT-23
R50, R53, R54, R57: 10k; R_0603_1608Metric
R55: 499; R_0603_1608Metric
R56: 40.2k; R_0603_1608Metric
TP73, TP74, TP75, TP78, TP79, TP80, TP81, TP82, TP83, TP84, TP85, TP135: Test-Point; TestPoint-0.75mm-th
TP76, TP77, TP127, TP128, TP129, TP130, TP131, TP132, TP133: Test-Point; TestPoint_Pad_D1.0mm
U1: OSD3358-512M-BSM; U-Octavo-OSD335X-BGA-256; MPN OSD3358-512M-BSM
U10: SN74AUC1G07DCKR; SOT-353_SC-70-5
U14: TLVH431; SOT-23

Connections:
3.3V: R50.2, R54.1, TP81.1, U1.F6 (SYS_VDD1_3P3V@1), U1.F7 (SYS_VDD1_3P3V@2), U1.G6 (SYS_VDD1_3P3V@3), U1.G7 (SYS_VDD1_3P3V@4); also elsewhere on the board
3.3VA: Q6.2 (E), R55.1, R57.1, TP84.1, U1.F8 (SYS_VDD3_3P3V@1), U1.F9 (VDDSHV4), U1.G8 (SYS_VDD3_3P3V@2), U1.G9 (VDDSHV5), U1.H7 (SYS_VDD3_3P3V@3), U1.H8 (SYS_VDD3_3P3V@4), U1.H9 (VDDSHV6), U1.J7 (SYS_VDD3_3P3V@5), U1.J8 (SYS_VDD3_3P3V@6), U1.J9 (VDDSHV1), U1.K8 (SYS_VDD3_3P3V@7), U1.K9 (VDDSHV2), U1.L8 (SYS_VDD3_3P3V@8), U1.L9 (VDDSHV3)
5V: C34.1, C65.1, C93.1, U1.P10 (VIN_AC@1), U1.R10 (VIN_AC@2), U1.T10 (VIN_AC@3); also elsewhere on the board
/OSD3358: SIP A/PMIC_GOOD: TP133.1, U1.N12 (PMIC_PGOOD), U1.P11 (PWRONRSTN), U10.2 (A)
/OSD3358: SIP A/SYS_RTC_1P8V: C78.1, Q6.3 (C), R56.2, TP83.1, U1.K11 (SYS_RTC_1P8V@1), U1.L11 (SYS_RTC_1P8V@2), U10.5 (VCC), U14.3 (A)
GND: C33.2, C34.2, C35.2, C36.2, C65.2, C78.2, C93.2, D8.1 (K), R53.1, TP79.1, U10.3 (GND); also elsewhere on the board
unnamed: D8.2 (A), R54.2
unnamed: Q6.1 (B), R55.2, U14.2 (K)
unnamed: TP75.1, U1.M2 (EEPROM_WP)
unnamed: TP132.1, U1.D4 (EXTINTN), U1.E4 (PMIC_NINT)
unnamed: TP131.1, U1.L4 (PMIC_NWAKEUP), U1.M4 (EXT_WAKEUP)
unnamed: TP73.1, U1.C10 (I2C0_SCL), U1.D10 (PMIC_SCL)
unnamed: TP74.1, U1.C11 (I2C0_SDA), U1.D11 (PMIC_SDA)
unnamed: TP77.1, U1.N7 (PMIC_BAT_SENSE), U1.P8 (VIN_BAT@1), U1.R8 (VIN_BAT@2), U1.T8 (VIN_BAT@3)
unnamed: TP130.1, U1.N4 (PMIC_LDO_PGOOD), U1.N5 (RTC_PWRONRSTN)
unnamed: TP127.1, U1.M13 (PMIC_NRESET)
unnamed: TP128.1, U1.T11 (PMIC_PB_IN)
unnamed: TP129.1, U1.N10 (PMIC_POWER_EN), U1.N11 (PMIC_PWR_EN)
unnamed: TP76.1, U1.N6 (PMIC_TS)
unnamed: R53.2, U1.M16 (RTC_KALDO_ENN)
unnamed: TP82.1, U1.F11 (SYS_VDD2_3P3V@1), U1.G11 (SYS_VDD2_3P3V@2)
unnamed: TP85.1, U1.F10 (SYS_VDD_1P8V@1), U1.G10 (SYS_VDD_1P8V@2), U1.H10 (SYS_VDD_1P8V@3), U1.H11 (SYS_VDD_1P8V@4), U1.J10 (SYS_VDD_1P8V@5), U1.J11 (SYS_VDD_1P8V@6), U1.K10 (SYS_VDD_1P8V@7), U1.L10 (SYS_VDD_1P8V@8)
unnamed: R56.1, R57.2, U14.1 (REF)
VDD: C36.1, TP80.1, U1.K6 (SYS_VOUT@1), U1.K7 (SYS_VOUT@2), U1.L6 (SYS_VOUT@3), U1.L7 (SYS_VOUT@4)
VIN_USB: C35.1, TP78.1, U1.P9 (VIN_USB@1), U1.R9 (VIN_USB@2), U1.T9 (VIN_USB@3); also elsewhere on the board
nRESET: C33.1, R50.1, TP135.1, U1.R11 (WARMRSTN), U10.4 (Y); also elsewhere on the board

Notes on the sheet:
1210
Providing DC to AC input?????
All resistors are 0603 1% AEC-Q200 unless marked. All capacitors are 0603 AEC-Q200 Vw >= 16V X5R or better unless marked.
SYS_VOUT
SYS_VDD_1P8V
Power from Backplane (Vbus via Vbusp) from 5V SPS
Needed for programming boot EEPROM TPS65217 I2C Addrs = 0x24 EEPROM I2C Addrs = 0x50
SYS_VDD3_3P3V
SYS_VDD1_3P3V is a 3.3V output of the OSD3358. It's generated from an internal TL5209 LDO. Imax = 500 mA, including draw from the OSD3358.
Power from Debug connector (USB client)
SYS_VDD2_3P3V
SYS_VDD1_3P3V
REMEMBER TO CONNECT 5V HERE
RTC_KALDO_ENN is grounded thru a 10K so that the internal RTC LDO is enabled and CAP_VDD_RTC does not need to be connected to VDD_CORE.
VBAT isn't used
SYS_VOUT is the OR of 5V from the bus and VIN_USB. Imax = 500 mA
5V Power in (OR'd)

Parts:
C56: 100n; C_0603_1608Metric
J4: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
J6: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R3: 120; R_0603_1608Metric
R72, R73, R74: 47k; Panasonic_Resistor_Array_EXBA10
TP32, TP49, TP90, TP113, TP114, TP115, TP116, TP117, TP118, TP119, TP120, TP121, TP123, TP125, TP134, TP136: Test-Point; TestPoint_Pad_D1.0mm
U1: OSD3358-512M-BSM; U-Octavo-OSD335X-BGA-256; MPN OSD3358-512M-BSM
U39: TCAN330; SOT-23-8

Connections:
3.3V: C56.1, R74.5 (55), R74.10 (55), U39.3 (VCC); also elsewhere on the board
/OSD3358: SIP D/CAN0_RX: U1.G16 (MII1_TXD2), U39.4 (RXD)
/OSD3358: SIP D/CAN0_TX: U1.G15 (MII1_TXD3), U39.1 (TXD)
CAN1+: R3.2, U39.7 (CANH); also elsewhere on the board
CAN1-: R3.1, U39.6 (CANL); also elsewhere on the board
GND: C56.2, J4.1, J6.2, R72.5 (55), R72.10 (55), R73.5 (55), R73.10 (55), U39.2 (GND); also elsewhere on the board
unnamed: J4.2, R74.4 (44), U1.L1 (LCD_DATA14)
unnamed: J4.3, R72.4 (44), U1.J1 (LCD_DATA8)
unnamed: J4.4, R72.7 (77), U1.K3 (LCD_DATA9)
unnamed: J4.5, R72.1 (11), U1.M3 (LCD_DATA15)
unnamed: J6.1, R74.8 (88), U1.G1 (LCD_DATA2)
unnamed: R72.2 (22), U1.L3 (LCD_DATA12)
unnamed: R72.3 (33), U1.K2 (LCD_DATA10)
unnamed: R72.6 (66), U1.J2 (LCD_DATA7)
unnamed: R72.8 (88), U1.K1 (LCD_DATA11)
unnamed: R72.9 (99), U1.L2 (LCD_DATA13)
unnamed: R73.1 (11), U1.G3 (LCD_DATA0)
unnamed: R73.2 (22), U1.G2 (LCD_DATA1)
unnamed: R73.4 (44), U1.H1 (LCD_DATA5)
unnamed: R73.7 (77), U1.J3 (LCD_DATA6)
unnamed: R74.3 (33), U1.H3 (LCD_DATA3)
unnamed: R74.6 (66), U1.H2 (LCD_DATA4)
unnamed: TP125.1, U1.F2 (LCD_HSYNC)
unnamed: TP123.1, U1.F1 (LCD_PCLK)
unnamed: TP134.1, U1.D13 (MDC)
unnamed: TP136.1, U1.E13 (MDIO)
unnamed: TP114.1, U1.F15 (MII1_COL)
unnamed: TP113.1, U1.F14 (MII1_CRS)
unnamed: TP116.1, U1.E14 (MII1_RXD0)
unnamed: TP117.1, U1.D16 (MII1_RXD1)
unnamed: TP118.1, U1.D15 (MII1_RXD2)
unnamed: TP119.1, U1.D14 (MII1_RXD3)
unnamed: TP115.1, U1.E16 (MII1_RX_CLK)
unnamed: TP121.1, U1.F16 (MII1_RX_DV)
unnamed: TP120.1, U1.E15 (MII1_RX_ER)
unnamed: TP90.1, U1.G14 (MII1_TX_EN)
unnamed: TP49.1, U39.8 (S)
unnamed: TP32.1, U39.5 (SHDN)

Notes on the sheet:
SYSBOOT[2] HIGH = eMMC SYSBOOT[2] LOW = uSD
SIP pin states ("ZZ", "LL", "ZL", etc) are GPIO states of the pin during and immediately after a reset. See Pg 18-47 in https://www.ti.com/lit/ds/symlink/am3358.pdf
Boot SD SYSBOOT[4:0] == 0b11000 SPI0 -> MMC0 -> USB0 -> UART0
All resistors are 0603 1% AEC-Q200 unless marked. All capacitors are 0603 AEC-Q200 Vw >= 16V X5R or better unless marked.
Boot eMMC SYSBOOT[4:0] == 0b11100 MMC1 -> MMC0 -> UART0 -> USB0
SYSBOOT[15:0] (Default) = 0x401C = 0100 0000 0001 1100
CAN Transceiver
SYSBOOT Jumper to config boot order must use very light pullups because boot config is latched at boot and then the pins a used for other purposes
Other settings: SYSBOOT[15:14] = 0b01 = 24 MHz Crystal SYSBOOT[5] = 0 = CLKOUT1 disabled
SYSBOOT[15 : 5] == 0b0100_0000_000
RTS
To main card connector
CTS

Parts:
C26, C27: 10p; C_0603_1608Metric
C28, C29: 18p; C_0603_1608Metric
C30, C32: 100n; C_0603_1608Metric
C31: 1n; C_0603_1608Metric
R46: NP; R_0603_1608Metric; not fitted
R47: 1M; R_0603_1608Metric
R75, R76, R77: 10k; R_0603_1608Metric
TP59: Test-Point; TestPoint-0.75mm-th
TP67, TP69, TP70, TP71, TP72, TP91, TP92, TP93, TP94, TP95, TP96, TP97, TP98, TP99, TP100, TP104, TP137, TP138, TP139: Test-Point; TestPoint_Pad_D1.0mm
U1: OSD3358-512M-BSM; U-Octavo-OSD335X-BGA-256; MPN OSD3358-512M-BSM
U11: RCLAMP0504FB; SOT-363_SC-70-6
Y1: ECS-240-12-30BQ-AEN-TR; CRYSTAL-5X3.2-4SMD
Y2: ABS07-32.768KHZ-T; CRYSTAL_3.2X1.5

Connections:
3.3V: R76.1, R77.1; also elsewhere on the board
/OSD3358: SIP B/OSC0_GND: C26.1, C27.1, U1.N15 (OSC0_GND), Y1.2, Y1.4
/OSD3358: SIP B/OSC0_IN: C26.2, R47.1, U1.P16 (OSC0_IN), Y1.1
/OSD3358: SIP B/OSC0_OUT: C27.2, R47.2, U1.N16 (OSC0_OUT), Y1.3
GND: C30.1, R75.2, U11.2 (GND); also elsewhere on the board
unnamed: C31.2, C32.2, U1.A9 (AGND_ADC), U1.B9 (VREFN)
unnamed: TP67.1, U1.C9 (AIN6)
unnamed: TP69.1, U1.D6 (PMIC_MUX_OUT), U1.D7 (AIN7)
unnamed: R77.2, TP95.1, U1.E2 (EMU0)
unnamed: R76.2, TP96.1, U1.E3 (EMU1)
unnamed: C28.1, C29.1, U1.B5 (OSC1_GND)
unnamed: C28.2, R46.1, U1.A6 (OSC1_IN), Y2.2
unnamed: C29.2, R46.2, U1.A5 (OSC1_OUT), Y2.1
unnamed: TP70.1, U1.N13 (PMIC_MUX_IN)
unnamed: C31.1, C32.1, TP59.1, U1.A7 (SYS_ADC_1P8V), U1.B7 (VREFP)
unnamed: TP93.1, U1.D1 (TCK)
unnamed: TP91.1, U1.C1 (TDI)
unnamed: TP92.1, U1.C2 (TDO)
unnamed: TP94.1, U1.D2 (TMS)
unnamed: R75.1, TP104.1, U1.D3 (TRSTN)
unnamed: TP138.1, U1.K13 (USB0_CE)
unnamed: TP139.1, U1.J15 (USB0_DRVVBUS)
unnamed: TP137.1, U1.K14 (USB0_ID)
unnamed: TP71.1, U1.L13 (USB1_CE)
unnamed: TP99.1, U1.L16 (USB1_DM)
unnamed: TP98.1, U1.L15 (USB1_DP)
unnamed: TP72.1, U1.M14 (USB1_DRVVBUS)
unnamed: TP97.1, U1.L14 (USB1_ID)
unnamed: TP100.1, U1.M15 (USB1_VBUS)
USB_CLI_DM: U1.K16 (USB0_DM), U11.1 (I1); also elsewhere on the board
USB_CLI_DP: U1.K15 (USB0_DP), U11.3 (I2); also elsewhere on the board
VIN_USB: C30.2, U1.J16 (USB0_VBUS), U11.5 (VCC); also elsewhere on the board
nRESET: U11.4 (I3); also elsewhere on the board

Notes on the sheet:
32.768 KHz XO
ALL ADC INPUTS MUST BE <= 1.8V MAXIMUM
To monitor TPS65217 PMIC voltages
SIP pin states ("ZZ", "LL", "ZL", etc) are GPIO states of the pin during and immediately after a reset. See Pg 18-47 in https://www.ti.com/lit/ds/symlink/am3358.pdf
See https://octavosystems.com/faqs/design-oscillator-circuit-osd335x-family-devices/#more-3862 to calculate 24 MHz crystal cap values.
24 MHz XO
1M if needed
32 KHz
Haven't needed JTAG so far
All resistors are 0603 1% AEC-Q200 unless marked. All capacitors are 0603 AEC-Q200 Vw >= 16V X5R or better unless marked.
We've really not used the USB host functionality, so we removed it, especially for the C3. The uSD card can be the main removable storage.
USB Client (goes upstream to PC)
24 MHz
USB ESD protection
SYS_ADC_1P8V and AGND_ADC are connected to SYS_VDD_1P8V and DGND through ferrite beads inside the SiP. Bypass capacitors should be added to reduce noise, if needed.
From Debug Connector (See Connectors Sheet)

Parts:
C1: 0.1u; C_0603_1608Metric
C2: 10u; C_0603_1608Metric
R4: 10k; R_0603_1608Metric
TP1, TP2, TP3, TP4: Test-Point; TestPoint-0.75mm-th
U2: MR20H40CDF; SON127P500X600X90-9N; PARTREV 12.6; DigiKey_Part_Number 819-1043-ND

Connections:
3.3V: C1.1, C2.1, R4.1, U2.3 (~WP), U2.7 (~HOLD), U2.8 (VDD); also elsewhere on the board
GND: C1.2, C2.2, U2.4 (VSS), U2.9 (VSS); also elsewhere on the board
MRAM_SPI_CLK: TP3.1, U2.6 (SCK); also elsewhere on the board
MRAM_SPI_CS: R4.2, TP4.1, U2.1 (~CS); also elsewhere on the board
MRAM_SPI_MISO: TP1.1, U2.2 (SO); also elsewhere on the board
MRAM_SPI_MOSI: TP2.1, U2.5 (SI); also elsewhere on the board

Parts:
C115: 100u; C_1210_3225Metric
C116, C117: 100n; C_0603_1608Metric
C131: 10n; C_0603_1608Metric
D10: 1N4151WS; D_SOD-323
D12: GREEN; LED_0603_1608Metric
Q1: NTR4101P; SOT-23
R49, R51, R66, R78, R79, R92, R93: 10k; R_0603_1608Metric
R67: 150; R_0603_1608Metric
R68, R80: 4.7k; R_0603_1608Metric
TP140: TestPoint_Pad_D1.0mm
TP141, TP148, TP149, TP160, TP164, TP165, TP168, TP169: Test-Point; TestPoint_Pad_D1.0mm
TP163: TestPoint-MinTH; TestPoint-0.75mm-th
U12: RCLAMP0504FB; SOT-363_SC-70-6
U24: RV-3028-C7; RV3028C732768KHZ1PPMTAQC
U30: FM24CL64B-DGTR; SOIC-8_3.9x4.9mm_P1.27mm
U37: LTC4300A-1; LINEAR-MSOP-8-AND-MAXIM-UMAX-8-21-0036

Connections:
3.3V: C131.1, Q1.3 (D), R49.1, R51.1, R78.2, R92.1, R93.1, TP163.1, U12.5 (VCC), U37.1 (ENABLE), U37.8 (VCC); also elsewhere on the board
GND: C115.2, C116.2, C117.2, C131.2, D12.1 (K), R66.2, R79.2, TP160.1, U12.2 (GND), U24.5 (VSS), U30.1 (A0), U30.2 (A1), U30.3 (A2), U30.4 (VSS), U30.7 (WP), U37.4 (GND); also elsewhere on the board
I2C1_SCL: R92.2, TP164.1, U12.1 (I1), U37.2 (SCLOUT); also elsewhere on the board
I2C1_SDA: R93.2, TP165.1, U12.3 (I2), U37.7 (SDAOUT); also elsewhere on the board
I2C1_SYS_SCL: R51.2, U37.3 (SCLIN); also elsewhere on the board
I2C1_SYS_SDA: R49.2, U37.6 (SDAIN); also elsewhere on the board
I2C2_SYS_DISABLE: Q1.1 (G), R66.1; also elsewhere on the board
I2C2_SYS_SCL: R80.2, TP168.1, U24.3 (SCL), U30.6 (SCL); also elsewhere on the board
I2C2_SYS_SDA: R68.2, TP169.1, U24.4 (SDA), U30.5 (SDA); also elsewhere on the board
unnamed: D10.2, R67.2
unnamed: D12.2 (A), R78.1
unnamed: C116.1, C117.1, Q1.2 (S), R67.1, R68.1, R80.1, U24.7 (VDD), U30.8 (VDD)
unnamed: TP141.1, U24.1 (CLKO)
unnamed: R79.1, TP149.1, U24.8 (EVI)
unnamed: C115.1, D10.1, U24.6 (VBKP)
unnamed: TP148.1, U24.2 (~INT)
unnamed: TP140.1, U37.5 (READY)

Notes on the sheet:
To OPD. See Connectors sheet.
FRAM
All resistors are 0603 1% AEC-Q200 unless marked. All capacitors are 0603 AEC-Q200 Vw >= 16V X5R or better unless marked.
Normally on; asserting I2C_SYS_DISABLE will turn off this subsystem.
IMPORTANT: To power down RTC/FRAM, OPD_PWR must be turned off as well to prevent pullup voltage bleeding through the LTC4300A-1.
I2C pullups provided by RTC/FRAM power PFET above.
Murata GRT32ER60J107ME13L 100uF 20% 6.3V X5R 1210 Capacitor
1210
HOW LONG WILL IT KEEP?
RTC
OreSat Power Domain (OPD) Control
