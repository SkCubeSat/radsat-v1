# Repository SkCubeSat/radsat-v1 (continued)

## KiCad design kicad/oresat-c3.kicad_pcb (continued)

Parts:
FB1: BLM18KG300JH1D; L_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad
J1, J2: Conn_02x26_Odd_Even; RHDR52W64P254_2X26_6654X495X1135P; Manufacturer_Part_Number ESQ-126-39-G-D-001; Mouser Part Number 200-ESQ12639GD001
J7: 2-1734592-0; J-TE-2-1734592-0
R2: 10; R_0603_1608Metric
TP36, TP37, TP40, TP41, TP43, TP44: Test-Point; TestPoint_Pad_D1.0mm

Connections:
5V: J2.25, J2.26; also elsewhere on the board
ADCS_ENABLE_CONTROL: J2.18; also elsewhere on the board
CAN1+: J1.1; also elsewhere on the board
CAN1-: J1.3; also elsewhere on the board
GND: H1.1, H2.1, H3.1, H4.1, J2.9, J2.14, J2.17, J2.21, J2.22, J2.29, J2.30, J2.32, J2.47, J2.48, J7.3 (GND), J7.6 (GND), J7.9 (GND), J7.PAD1 (PAD), J7.PAD2 (PAD); also elsewhere on the board
GPIO1: J1.5
GPIO2: J1.6
GPIO3: J1.7
GPIO4: J1.8
GPIO5: J1.45
GPIO6: J1.46
GPIO7: J1.47
GPIO8: J1.48
GPIO9: J1.49
GPIO10: J1.50
I2C1_SCL: J1.43; also elsewhere on the board
I2C1_SDA: J1.41; also elsewhere on the board
I2C2_SCL: J1.23; also elsewhere on the board
I2C2_SDA: J1.21; also elsewhere on the board
unnamed: FB1.1, J7.1 (VBUSP), J7.2 (VBUSP)
unnamed: J7.17 (DEBUG-0), TP40.1
unnamed: J7.18 (DEBUG-1), TP41.1
unnamed: J7.19 (DEBUG-2), TP43.1
unnamed: J7.20 (DEBUG-3), TP44.1
unnamed: J7.7 (HOST-D+), TP36.1
unnamed: J7.8 (HOST-D-), TP37.1
unnamed: J7.10 (NRST), R2.1
UART0_RX: J7.12 (CARD-RX); also elsewhere on the board
UART0_TX: J7.13 (CARD-TX); also elsewhere on the board
UART1_RX: J1.34; also elsewhere on the board
UART1_TX: J1.33; also elsewhere on the board
UART2_RX: J1.36
UART2_TX: J1.35
UART3_RX: J1.38
UART3_TX: J1.37
UART4_RX: J1.18
UART4_TX: J1.17
USB_CLI_DM: J7.5 (DEVICE-D-); also elsewhere on the board
USB_CLI_DP: J7.4 (DEVICE-D+); also elsewhere on the board
VIN_USB: FB1.2; also elsewhere on the board
nRESET: R2.2; also elsewhere on the board

Notes on the sheet:
Powers Octavo but not radios
Called C3-UART-TX
Unused (Used by Magnetomers on ADCS Card)
USB Device (Ethernet over USB)
Oresat Card RF Connectors
Oresat Card Debug Connector
Called C3-UART-RX
Octavo reset!
CSKB HEADERS
SMPM Connectors to Backplane
30Ω / 1.8A
20 pin FFC Connector
Same as C3-UART
All resistors are 0603 1% AEC-Q200 unless marked. All capacitors are 0603 AEC-Q200 Vw >= 16V X5R or better unless marked.

Parts:
TP19, TP20, TP21, TP22: Test-Point; TestPoint_Pad_D1.0mm
U1: OSD3358-512M-BSM; U-Octavo-OSD335X-BGA-256; MPN OSD3358-512M-BSM

Connections:
GND: U1.D8 (DGND@1), U1.D9 (DGND@2), U1.E5 (DGND@3), U1.E6 (DGND@4), U1.E7 (DGND@5), U1.E8 (DGND@6), U1.E9 (DGND@7), U1.E10 (DGND@8), U1.E11 (DGND@9), U1.E12 (DGND@10), U1.F5 (DGND@11), U1.F12 (DGND@12), U1.G5 (DGND@13), U1.G12 (DGND@14), U1.H4 (DGND@15), U1.H5 (DGND@16), U1.H12 (DGND@17), U1.H13 (DGND@18), U1.J4 (DGND@19), U1.J5 (DGND@20), U1.J12 (DGND@21), U1.J13 (DGND@22), U1.K5 (DGND@23), U1.K12 (DGND@24), U1.L5 (DGND@25), U1.L12 (DGND@26), U1.M5 (DGND@27), U1.M6 (DGND@28), U1.M7 (DGND@29), U1.M8 (DGND@30), U1.M9 (DGND@31), U1.M10 (DGND@32), U1.M11 (DGND@33), U1.M12 (DGND@34), U1.N8 (DGND@35), U1.N9 (DGND@36); also elsewhere on the board
unnamed: TP19.1, U1.F4 (VDDS_DDR)
unnamed: TP22.1, U1.G13 (VDDS_PLL)
unnamed: TP20.1, U1.G4 (VDD_CORE)
unnamed: TP21.1, U1.F13 (VDD_MPU)

Notes on the sheet:
All resistors are 0603 1% AEC-Q200 unless marked. All capacitors are 0603 AEC-Q200 Vw >= 16V X5R or better unless marked.

Schematic: oresat-c3-sch-osd3358-sd-emmc.kicad_sch, OreSat C3: OSD3358 SIP C

Parts:
C16, C25: 10u; C_0805_2012Metric
C17: 100n; C_0603_1608Metric
C19, C20, C21, C22, C23, C24: 1u; C_0603_1608Metric
D4, D5, D6, D7: BLUE; LED_0603_1608Metric
J5: DM3BT-DSF-PEJS; J-Hirose-DM3BT-DSF-PEJS
Q2: SI7106DN-T1-GE3; SIS862DNT1GE3; Mouser Part Number 781-SI7106DN-T1-GE3
R6: 20k; R_0603_1608Metric
R26, R27, R42, R43, R44, R45, R90, R104, R118: 10k; R_0603_1608Metric
R69, R70, R71: 10k; Panasonic_Resistor_Array_EXBA10
TP38, TP39, TP46, TP47, TP48, TP64, TP65, TP66, TP68: Test-Point; TestPoint_Pad_D1.0mm
U1: OSD3358-512M-BSM; U-Octavo-OSD335X-BGA-256; MPN OSD3358-512M-BSM
U9: EMMC+RESET+5.1-COMPATIBLE-BA; BGA-153(11.5X13)(EMMC-BA)

Connections:
3.3V: C16.1, C17.1, C21.1, C22.1, C23.1, C24.1, C25.1, J5.4 (VDD), R26.1, R27.1, R69.5 (55), R69.10 (55), R70.5 (55), R70.10 (55), R71.5 (55), R71.10 (55), R90.1, R104.1, R118.1, U9.C6 (VDDQ), U9.E6 (VDDIO), U9.F5 (VDDIO), U9.J10 (VDDIO), U9.K9 (VDDIO), U9.M4 (VDDQ), U9.N4 (VDDQ), U9.P3 (VDDQ), U9.P5 (VDDQ); also elsewhere on the board
/OSD3358: SIP C/EMMC_CMD: R70.2 (22), U1.P1 (GPMC_CSN2), U9.M5 (CMD)
/OSD3358: SIP C/EMMC_D0: R70.6 (66), U1.R3 (GPMC_AD0), U9.A3 (D0)
/OSD3358: SIP C/EMMC_D1: R71.1 (11), U1.R2 (GPMC_AD1), U9.A4 (D1)
/OSD3358: SIP C/EMMC_D2: R71.9 (99), U1.R1 (GPMC_AD2), U9.A5 (D2)
/OSD3358: SIP C/EMMC_D3: R70.7 (77), U1.T3 (GPMC_AD3), U9.B2 (D3)
/OSD3358: SIP C/EMMC_D4: R70.4 (44), U1.T2 (GPMC_AD4), U9.B3 (D4)
/OSD3358: SIP C/EMMC_D5: R70.3 (33), U1.T1 (GPMC_AD5), U9.B4 (D5)
/OSD3358: SIP C/EMMC_D6: R71.8 (88), U1.P4 (GPMC_AD6), U9.B5 (D6)
/OSD3358: SIP C/EMMC_D7: R71.2 (22), U1.R4 (GPMC_AD7), U9.B6 (D7)
/OSD3358: SIP C/EMMC_SCK: R70.8 (88), U1.P2 (GPMC_CSN1), U9.M6 (SCK)
/OSD3358: SIP C/EMMC_nRST: R71.3 (33), U1.R13 (GPMC_A4), U9.K5 (~RST)
/OSD3358: SIP C/MMC1_CD: J5.CD (CD#), R69.6 (66), U1.C14 (SPI0_CS1)
/OSD3358: SIP C/MMC1_CLK: J5.5 (CLK), R69.3 (33), U1.B15 (MMC0_CLK)
/OSD3358: SIP C/MMC1_CMD: J5.3 (CMD/DI), R69.8 (88), U1.B16 (MMC0_CMD)
/OSD3358: SIP C/MMC1_DAT0: J5.7 (DAT0/DO), R69.9 (99), U1.A16 (MMC0_DAT0)
/OSD3358: SIP C/MMC1_DAT1: J5.8 (DAT1), R69.4 (44), U1.A15 (MMC0_DAT1)
/OSD3358: SIP C/MMC1_DAT2: J5.1 (DAT2), R69.7 (77), U1.C16 (MMC0_DAT2)
/OSD3358: SIP C/MMC1_DAT3: J5.2 (DAT3/CS), R69.2 (22), U1.C15 (MMC0_DAT3)
/OSD3358: SIP C/USR1: R42.1, U1.P13 (GPMC_A5)
/OSD3358: SIP C/USR2: R43.1, U1.T14 (GPMC_A6)
/OSD3358: SIP C/USR3: R44.1, U1.R14 (GPMC_A7)
/OSD3358: SIP C/USR4: R45.1, U1.P14 (GPMC_A8)
ADCS_ENABLE_CONTROL: Q2.5 (D_1), Q2.6 (D_2), Q2.7 (D_3), Q2.8 (D_4), Q2.9 (D_5), Q2.10 (D_6), Q2.11 (D_7); also elsewhere on the board
ADCS_UART_GNSS: U1.A3 (MCASP0_ACLKR), U1.C5 (ECAP0_IN_PWM0_OUT)
GND: C16.2, C17.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), J5.6 (VSS), J5.CGND1 (CGND), J5.CGND2 (CGND), J5.CGND3 (CGND), J5.CGND4 (CGND), J5.CGND5 (CGND), J5.CGND6 (CGND), J5.GND (VSS), Q2.1 (S_1), Q2.2 (S_2), Q2.3 (S_3), R6.2, U9.A2 (NC), U9.A6 (VSSIO), U9.B7 (NC), U9.C4 (VSSQ), U9.E7 (VSSIO), U9.G5 (VSSIO), U9.H10 (VSSIO), U9.J5 (VSSIO), U9.K8 (VSSIO), U9.N2 (VSSQ), U9.N5 (VSSQ), U9.P4 (VSSQ), U9.P6 (VSSQ); also elsewhere on the board
I2C1_SYS_SCL: U1.A14 (SPI0_CS0); also elsewhere on the board
I2C1_SYS_SDA: U1.B14 (SPI0_D1); also elsewhere on the board
I2C2_SYS_DISABLE: U1.R6 (GPMC_AD13); also elsewhere on the board
I2C2_SYS_SCL: U1.A10 (UART1_RTSN); also elsewhere on the board
I2C2_SYS_SDA: U1.B10 (UART1_CTSN); also elsewhere on the board
MRAM_SPI_CLK: U1.A1 (MCASP0_ACLKX); also elsewhere on the board
MRAM_SPI_CS: U1.B1 (MCASP0_AHCLKR); also elsewhere on the board
MRAM_SPI_MISO: U1.A2 (MCASP0_FSX); also elsewhere on the board
MRAM_SPI_MOSI: U1.B2 (MCASP0_AXR0); also elsewhere on the board
unnamed: D4.2 (A), R42.2
unnamed: D5.2 (A), R43.2
unnamed: D6.2 (A), R44.2
unnamed: D7.2 (A), R45.2
unnamed: Q2.4 (G), R6.1, TP46.1, U1.P7 (GPMC_AD15)
unnamed: TP38.1, U1.R12 (GPMC_A1)
unnamed: TP39.1, U1.P12 (GPMC_A2)
unnamed: R26.2, U1.T4 (GPMC_AD8)
unnamed: R27.2, U1.P5 (GPMC_AD9)
unnamed: R90.2, U1.R5 (GPMC_AD10)
unnamed: R104.2, U1.T5 (GPMC_AD11)
unnamed: R118.2, U1.P6 (GPMC_AD12)
unnamed: TP64.1, U1.N3 (GPMC_BEN0_CLE)
unnamed: TP68.1, U1.T7 (GPMC_CLK)
unnamed: TP47.1, U1.P3 (GPMC_CSN0)
unnamed: TP48.1, U1.R7 (GPMC_CSN3)
unnamed: TP66.1, U1.N1 (GPMC_OEN_REN)
unnamed: TP65.1, U1.N2 (GPMC_WEN)
unnamed: C19.1, C20.1, U9.C2 (VDDI)
UART0_RX: U1.A12 (UART0_RXD); also elsewhere on the board
UART0_TX: U1.B12 (UART0_TXD); also elsewhere on the board
UART1_RX: U1.A11 (UART1_RXD); also elsewhere on the board
UART1_TX: U1.B11 (UART1_TXD); also elsewhere on the board

Notes on the sheet:
0805
5 bits (32 max). Set pins to inputs with pull-downs, and stuffed resistors will pull up pins.
eMMC Flash Memory
SPI INTERFACE FOR KUBOS
Removable uSD Card
C3 Hardware ID
Need ~2.2uF, using two 1uF for simplicity
Bit 0
SIP pin states ("ZZ", "LL", "ZL", etc) are GPIO states of the pin during and immediately after a reset. See Pg 18-47 in https://www.ti.com/lit/ds/symlink/am3358.pdf
USR LEDs
Z[L|0|CLK]
Bit 4
TO C3 I2C Peripherals
All resistors are 0603 1% AEC-Q200 unless marked. All capacitors are 0603 AEC-Q200 Vw >= 16V X5R or better unless marked.
USE B14 AND A14 AS I2C1 BUS

Board: 4 copper layers, 90.2 x 95.9 mm, 204 parts (55 on the bottom side), 172 nets.

Other parts of the board:
C3: 10n; C_0603_1608Metric
R1, R5, R7, R8: 10k; R_0603_1608Metric
TP5: TestPoint_Pad_D1.0mm
TP6: TestPoint-MinTH; TestPoint-0.75mm-th
TP7, TP8: Test-Point; TestPoint_Pad_D1.0mm
U3: LTC4300A-1; LINEAR-MSOP-8-AND-MAXIM-UMAX-8-21-0036
U4: RCLAMP0504FB; SOT-363_SC-70-6

Their connections:
3.3V: C3.1, R1.1, R5.1, R7.1, R8.1, TP6.1, U3.1 (ENABLE), U3.8 (VCC), U4.5 (VCC); also elsewhere on the board
GND: C3.2, U3.4 (GND), U4.2 (GND); also elsewhere on the board
I2C2_SCL: R7.2, TP7.1, U3.2 (SCLOUT), U4.1 (I1); also elsewhere on the board
I2C2_SDA: R8.2, TP8.1, U3.7 (SDAOUT), U4.3 (I2); also elsewhere on the board
I2C2_SYS_SCL: R1.2, U3.3 (SCLIN); also elsewhere on the board
I2C2_SYS_SDA: R5.2, U3.6 (SDAIN); also elsewhere on the board
unnamed: TP5.1, U3.5 (READY)

File kicad/pcbway_production/2026-02-27-20-54-22/oresat-c3.kicad_pcb_bom.csv (part):

Designator,Quantity,Value,Footprint,Package,MPN,DNP,Mount_Type,Description,Manufacturer_Name,Description / Value,Height,Mouser Part Number,Mouser Price/Stock,Arrow Part Number,Arrow Price/Stock,Distributor,DigiKey_Part_Number,SnapEDA_Link,MAXIMUM_PACKAGE_HEIGHT,Check_prices,STANDARD,PARTREV,MF,MP,Description_1,MANUFACTURER
C1,1,0.1u,C_0603_1608Metric,,GCJ188R71C104KA01D,,smt,"Unpolarized capacitor, small symbol",Murata Electronics,CAP CER 0.1UF 16V X7R 0603,,,,,,,,,,,,,,,,
C115,1,100u,C_1210_3225Metric,,GRT32ER60J107ME13L,,smt,,Murata Electronics,CAP CER 100UF 6.3V X5R 1210,,,,,,,,,,,,,,,,
"C116, C117, C17, C30, C32, C33, C56, C65, C78",9,100n,C_0603_1608Metric,,GCJ188R71C104KA01D,,smt,,Murata Electronics,CAP CER 0.1UF 16V X7R 0603,,,,,,,,,,,,,,,,
"C131, C3, C4, C5, C6",5,10n,C_0603_1608Metric,,CL10B103KO8WPNC,,smt,,Samsung Electro-Mechanics,CAP CER 10NF 16V X7R 0603,,,,,,,,,,,,,,,,
"C16, C25",2,10u,C_0805_2012Metric,,GRT21BR61C106KE01L,,smt,,Murata Electronics,CAP CER 10UF 16V X5R 0805,,,,,,,,,,,,,,,,
"C19, C20, C21, C22, C23, C24",6,1u,C_0603_1608Metric,,GCM188R71C105KA64D,,smt,,Murata Electronics,CAP CER 1UF 16V X7R 0603,,,,,,,,,,,,,,,,
C2,1,10u,C_0603_1608Metric,,GRT188R61C106KE13D,,smt,"Unpolarized capacitor, small symbol",Murata Electronics,CAP CER 10UF 16V X5R 0603,,,,,,,,,,,,,,,,
"C26, C27",2,10p,C_0603_1608Metric,,C0603C100K4RACAUTO,,smt,,KEMET,CAP CER 10PF 16V X7R 0603,,,,,,,,,,,,,,,,
"C28, C29",2,18p,C_0603_1608Metric,,GCM1885C1H180JA16D,,smt,,Murata Electronics,CAP CER 18PF 50V C0G/NP0 0603,,,,,,,,,,,,,,,,
C31,1,1n,C_0603_1608Metric,,GCM188R71H102KA37D,,smt,,Murata Electronics,CAP CER 1000PF 50V X7R 0603,,,,,,,,,,,,,,,,
"C34, C35, C36, C93",4,22u,C_1210_3225Metric,,GCM32ER71C226KE19L,,smt,,Murata Electronics,CAP CER 22UF 16V X7R 1210,,,,,,,,,,,,,,,,
D10,1,1N4151WS,D_SOD-323,,1N4151WS-G3-08,,smt,,Vishay General Semiconductor - Diodes Division,DIODE STANDARD 50V 150MA SOD323,,,,,,,,,,,,,,,,
D12,1,GREEN,LED_0603_1608Metric,,,Yes,smt,,,,,,,,,,,,,,,,,,,
D4,1,BLUE,LED_0603_1608Metric,,,Yes,smt,,,,,,,,,,,,,,,,,,,
D5,1,BLUE,LED_0603_1608Metric,,,Yes,smt,,,,,,,,,,,,,,,,,,,
D6,1,BLUE,LED_0603_1608Metric,,,Yes,smt,,,,,,,,,,,,,,,,,,,
D7,1,BLUE,LED_0603_1608Metric,,,Yes,smt,,,,,,,,,,,,,,,,,,,
D8,1,GREEN,LED_0603_1608Metric,,,Yes,smt,,,,,,,,,,,,,,,,,,,
FB1,1,BLM18KG300JH1D,L_0603_1608Metric,,BLM18KG300JH1D,,smt,,Murata Electronics,FERRITE BEAD 30 OHM 0603 1LN,,,,,,,,,,,,,,,,
H1,1,MountingHole_Pad,MountingHole_3.2mm_M3_ISO7380_Pad,,,Yes,tht,,,,,,,,,,,,,,,,,,,
H2,1,MountingHole_Pad,MountingHole_3.2mm_M3_ISO7380_Pad,,,Yes,tht,,,,,,,,,,,,,,,,,,,
H3,1,MountingHole_Pad,MountingHole_3.2mm_M3_ISO7380_Pad,,,Yes,tht,,,,,,,,,,,,,,,,,,,
H4,1,MountingHole_Pad,MountingHole_3.2mm_M3_ISO7380_Pad,,,Yes,tht,,,,,,,,,,,,,,,,,,,
"J1, J2",2,Conn_02x26_Odd_Even,RHDR52W64P254_2X26_6654X495X1135P,,ESQ-126-39-G-D,,tht,"PC / 104 Connectors Elevated Socket Strip, 0.100 Pitch",Samtec Inc.,CONN SOCKET 52POS 0.1 GOLD PCB,11.35,200-ESQ12639GD001,https://www.mouser.co.uk/ProductDetail/Samtec/ESQ-126-39-G-D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,ESQ-126-39-G-D-001,https://www.arrow.com/en/products/esq-126-39-g-d-001/samtec?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,,,,,,,,,,,
J3,1,Conn_01x03,PinHeader_1x03_P2.54mm_Horizontal,,TSW-103-25-F-S-RA,,tht,"Generic connector, single row, 01x03, script generated (kicad-library-utils/schlib/autogen/connector/)",Samtec Inc.,CONN HEADER R/A 3POS 2.54MM,,,,,,,,,,,,,,,,
J4,1,Conn_01x05,PinHeader_1x05_P2.54mm_Horizontal,,TSW-105-25-F-S-RA,,tht,"Generic connector, single row, 01x05, script generated (kicad-library-utils/schlib/autogen/connector/)",Samtec Inc.,CONN HEADER R/A 5POS 2.54MM,,,,,,,,,,,,,,,,
J5,1,DM3BT-DSF-PEJS,J-Hirose-DM3BT-DSF-PEJS,,DM3BT-DSF-PEJS,,tht,,Hirose Electric Co Ltd,CONN MICRO SD CARD R/A SMD,,,,,,,,,,,,,,,,
J6,1,Conn_01x02,M20-8890245,,M20-8890245,,smt,,Harwin Inc.,CONN HEADER SMD R/A 2POS 2.54MM,,,,,,,,,,,,,,,,
J7,1,2-1734592-0,J-TE-2-1734592-0,,2-1734592-0,,tht,,TE Connectivity AMP Connectors,CONN FPC BOTTOM 20POS 0.5MM R/A,,,,,,,,,,,,,,,,
Q1,1,NTR4101P,SOT-23,,NTR4101PT1H,,smt,,onsemi,MOSFET P-CH 20V 1.8A SOT23-3,,,,,,,,,,,,,,,,
Q2,1,SI7106DN-T1-GE3,SIS862DNT1GE3,,SI7106DN-T1-GE3,,smt,MOSFET 20V Vds 12V Vgs PowerPAK 1212-8,Vishay Siliconix,MOSFET N-CH 20V 12.5A PPAK1212-8,1.12,781-SI7106DN-T1-GE3,https://www.mouser.co.uk/ProductDetail/Vishay-Semiconductors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,,,,,,,,,,,,,
Q6,1,MMBT2907,SOT-23,,"PMBT2907A,235",,smt,,"Shenzhen Slkormicro Semicon Co., Ltd.","40V 250MW 100@150MA,10V 600MA PN",,,,,,,,,,,,,,,,
"R1, R104, R118, R26, R27, R4, R49, R5, R50, R51, R53, R57, R66, R7, R75, R76, R77, R79, R8, R90, R92, R93",22,10k,R_0603_1608Metric,,RMCA0603FT10K0-HP,,smt,,Stackpole Electronics Inc,RES 0603 10 KOHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
R2,1,10,R_0603_1608Metric,,RMCA0603FT10R0-HP,,smt,,Stackpole Electronics Inc,RES 0603 10 OHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
R3,1,120,R_0603_1608Metric,,RMCA0603FT120R-HP,,smt,,Stackpole Electronics Inc,RES 0603 120 OHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
R42,1,10k,R_0603_1608Metric,,RMCA0603FT10K0-HP,Yes,smt,,Stackpole Electronics Inc,RES 0603 10 KOHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
R43,1,10k,R_0603_1608Metric,,RMCA0603FT10K0-HP,Yes,smt,,Stackpole Electronics Inc,RES 0603 10 KOHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
R44,1,10k,R_0603_1608Metric,,RMCA0603FT10K0-HP,Yes,smt,,Stackpole Electronics Inc,RES 0603 10 KOHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
R45,1,10k,R_0603_1608Metric,,RMCA0603FT10K0-HP,Yes,smt,,Stackpole Electronics Inc,RES 0603 10 KOHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
R46,1,NP,R_0603_1608Metric,,,Yes,smt,,,,,,,,,,,,,,,,,,,
R47,1,1M,R_0603_1608Metric,,RMCA0603FT1M00-HP,,smt,,Stackpole Electronics Inc,RES 0603 1 MOHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
R54,1,10k,R_0603_1608Metric,,RMCA0603FT10K0-HP,Yes,smt,,Stackpole Electronics Inc,RES 0603 10 KOHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
R55,1,499,R_0603_1608Metric,,RMCA0603FT499R-HP,,smt,,Stackpole Electronics Inc,RES 0603 499 OHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
R56,1,40.2k,R_0603_1608Metric,,5.60112E+11,,smt,,Würth Elektronik,RES 40.2K OHM 1% 1/10W 0603,,,,,,,,,,,,,,,,
R6,1,20k,R_0603_1608Metric,,RMCA0603FT20K0-HP,,smt,,Stackpole Electronics Inc,RES 0603 20 KOHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
R67,1,150,R_0603_1608Metric,,RMCA0603FT150R-HP,,smt,,Stackpole Electronics Inc,RES 0603 150 OHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
"R68, R80",2,4.7k,R_0603_1608Metric,,RMCA0603FT4K70-HP,,smt,,Stackpole Electronics Inc,RES 0603 4.7 KOHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
"R69, R70, R71",3,10k,Panasonic_Resistor_Array_EXBA10,,EXB-A10P473J,,tht,,Panasonic Electronic Components,RES ARRAY 8 RES 47K OHM 2512,,,,,,,,,,,,,,,,
"R72, R73, R74",3,47k,Panasonic_Resistor_Array_EXBA10,,EXB-A10P473J,,tht,,Panasonic Electronic Components,RES ARRAY 8 RES 47K OHM 2512,,,,,,,,,,,,,,,,
R78,1,10k,R_0603_1608Metric,,RMCA0603FT10K0-HP,Yes,smt,,Stackpole Electronics Inc,RES 0603 10 KOHM 1% 0.125W AUTO,,,,,,,,,,,,,,,,
TP10,1,Test-Point,TestPoint-0.75mm-th,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP100,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP104,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP113,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP114,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP115,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP116,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP117,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP118,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP119,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP120,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP121,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP123,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP125,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP127,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP128,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
TP129,1,Test-Point,TestPoint_Pad_D1.0mm,,,Yes,tht,,,,,,,,,,,,,,,,,,,
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
## Commit log

2024-02-16 Initial commit with oresat OBC kicad files
2024-02-19 Added Oresat symbol lib. Removed any L-band related components from pcb and schematic
2024-02-19 Removed UF band
2024-02-20 Removed power switching circuitry
2024-02-20 Removed antenna deployers
2024-02-20 Removed antenna deployers, fixed
2024-02-20 Finished removing components and rerouting. Still need to place voltage and GND planes
2024-02-24 Added Power and ground planes, still need to fix a few things
2024-02-24 Fixed power plane issues
2024-02-25 Fixed most DRC checks
2024-02-25 Added logos
2024-02-25 Fixed some issues, still need to clear DRC
2024-02-28 Clear all DRC errors
2024-03-09 Added GND fences to traces
2024-03-15 Added radsat logo
2024-03-15 created BOM and gerber
2024-03-15 Credited oresat
2024-10-03 Created BOM for ordering
2024-10-03 Increased trace width on 5V AC_Input
2024-10-04 Fixed FFC connector orientation
2024-10-15 Switched 3.3V generation from CSKB to OSD3358
2024-10-17 Added mounting holes
2024-10-17 Modified CSKB pinout to correct format, also made sure it is PC104 standard
2024-10-30 Redid 3v3 power scheme
2024-10-31 Added I2C1 bus lines
2024-11-01 Removed Logos
2024-11-04 Fixed silkscreen labels
2024-11-07 Removed OPD and added LTC4300A to I2C1 bus
2024-11-07 Added CAN bus termination resistors
2024-11-08 Added GPIO enable pins for ADCS
2024-11-08 Switched 5V on AC_Input to a plane instead of traces
2024-11-09 Brought out some pins that need to be used for UART SLIP connection on sysboot schematic
2024-11-09 Added via stitching
2024-11-12 Added UART TX pin for ADCS GNSS. Also fixed I2C SDA/SCL, they were swapped accidently
2025-01-27 pcb changes
2025-01-29 Removed floating metal pours with via filling
2025-01-30 Removed watchdog
2025-01-30 Reworked 3v3 pour on In2 Layer
2025-02-04 Added MRAM chip to board
2025-02-06 Added extra decoupling capacitor to MRAM. Also grounded all unused pins and mounting holes
2025-02-10 Re-orientated silkscreen and added more via fencing. Also fixed BOM
2025-02-12 Fixed skew on CAN lines
2025-02-13 Added CTS and RTS pin to UART header. Re-arranged silkscreens. Added Silkscreen labels to CSKB. Added fencing on I2C lines
2025-02-13 Fixed ADCS Labels
2025-02-19 Created BOM
2026-01-07 Prep for PC104 Update
2026-01-11 Updated PCB to the new PC104 template form factor
2026-01-11 Resolved library conflicts and added 3D models
2026-01-18 Updated PC104 connector with current version
2026-01-22 - Locked CSKB Headers on PCB - Removed CAN1 from schematic - Removed ADCS boot enable from schematic - Removed unnecessary grounds from PCB
2026-01-22 forgot to save pcb for previous commit
2026-01-29 Finished Labelling CSKB - Removed old UART GNSS Pin, no longer needed - Labelled GPIOs on CSKB - Mapped all available GPIOs in BBB Sheet - Labelled UART lines on CSKB
2026-01-31 - Grounded FRAM Write protect permanently - Erased old CAN transceivers for unused bus - Fixed CAN termination resistor value to 120 ohm - Redid Clock skew for CAN lines - Removed UART0 from CSKB - A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
2026-01-31 - Labelled GPIOs and UART lines to processor pins - Routed UART lines - Routed GPIO Lines - Refilled zones - Added via fencing back in - Board should be ready to be reviewed now
2026-02-01 OBC review session changes
2026-02-04 Added 2 new GPIO pins
2026-02-04 - Configured pin headers for UART5 and boot pins to be horizontal - Removed some TPs for GPIO pins
2026-02-05 Moved connectors around, still needs to be routed
2026-02-06 - Routed New boot pin properly, added test points to old spots as backups - Filled some floating ground planes with vias near I2C2 Buffer - Routed UART0 to new pins properly - Fixed SD card connector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
2026-02-06 - Verified no copper pours - Verified the GPIO traces again - Labelled bottom of CSKB - Fixed Antenna on I2C2 Line (internal) - Went through DRC and fixed any real errors not related to footprints or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
2026-02-06 Added ground fencing via grid
2026-02-08 - Removed ground from mounting holes - Moves SLIP header lower so it doesnt go off edge of PCB
2026-02-08 moved around silkscreen
2026-02-16 added automotive grade capacitors to the BOM
2026-02-16 added automotive grade resistors to BOM
2026-02-16 modified BOM to match PCBWay format
2026-02-16 finished putting together BOM, needs review
2026-02-18 - Fixed part number for FRAM, CAN transceiver, emmc, and BJT - Change LED and connected resistors to DNP - Verified remainder of components
2026-02-19 - Increased thermal relief size for Ground pads and some 3v3 pads - Made slight improvements to routing for I2C, UART lines - Uart 4 moved to not cross over power plane - Added stitching capacitor ne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
2026-02-19 - Adjusted some GND/3.3V thermal reliefs - Added teardrops for all trace connections to vias and pads - Placed few extra GND vias to better connect ground pours and prevent cross talk (SPI)
2026-02-19 Adjusted CAN differential pair
2026-02-21 moved SD card boot pin to the top of the board
2026-02-21 - removed C5 pin connected to GPIO4/A3 - Redid teardrops - fixed one DRC issue with a via
2026-02-22 Changed trace clearance to meet requirements for PCBWay 2 oz copper
2026-02-22 Fixed GPIO4 and increased trace widths, added stitching vias to reduce parasitic cap.
2026-02-22 Removed ground vias interfering with current traces
2026-02-22 - Fixed gpio4 again, C5 is the final correct pin, do not need to connect to A3 - fixed canBus net to be correct length - Fixed one DRC issue, remaining issues are not to be concerned with
2026-02-22 Updated board constraints
2026-02-22 Manually reverting KiCad files to state before ff5831f due to conflicts
2026-02-22 Restored GPIO 4 and re-fized canbus trace width
2026-02-24 Increased annular width for most vias (except for those on the emmc), made sure all constraints were met
2026-02-24 - Modified trace width for I2C, UART to 0.25 mm - Might still modify the traces of UART4 that connect to the OSD
2026-02-25 Changed spi trace width to 0.25 mm
2026-02-25 Re-added stitching vias and fixed routing for some GPIOs
2026-02-26 Removed random edge cut line
2026-02-28 Final checks before ordering. PM approved
2026-02-28 Fixed some BOM issues. Board has been ordered, generated production files
2026-02-28 Created stp file of the board for the Mechanical team
2026-05-07 Adjusted silkscreen for easier assembly inspection
2026-05-08 Added ESD label
2026-05-08 Added fiducials to top layer
2026-05-08 Finished adding fiducials to top and bottom layers
2026-05-08 Finished rerouting CAN
2026-05-09 Fixed i2c teardrops
2026-05-09 Removed vias okay thanks bye
2026-05-09 Fixed teardrops im crine
2026-05-09 Fixed DRC errors, created new BOM, submitted new order to PCBway
